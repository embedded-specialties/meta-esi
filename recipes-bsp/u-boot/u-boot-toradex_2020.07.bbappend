FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Removed-bootaux-command.patch \
            file://0002-Added-ESI-logo-image-file.patch \
            "

